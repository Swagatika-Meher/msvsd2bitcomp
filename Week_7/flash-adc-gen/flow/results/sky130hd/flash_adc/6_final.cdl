$ CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT flash_adc T_1 T_2 T_3 T_4 T_5 T_6 T_7 Y1 Y2 Y3 vin
+ VSS VDD r_VDD(0) r_VDD(1) r_VDD(2) r_VDD(3) r_VDD(4) r_VDD(5)
+ r_VDD(6) r_VDD(7) r_VDD(8) r_VSS(0) r_VSS(1) r_VSS(2) r_VSS(3)
+ r_VSS(4) r_VSS(5) r_VSS(6) r_VSS(7) r_VSS(8)
